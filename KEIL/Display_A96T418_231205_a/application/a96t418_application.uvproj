# Keil uVision project a96t418_application.uvproj, settings and files
target A96T418 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: t418code +hex
  c flags: Optimize=9
  c include: .\source;..\common;..\library\header
  asm include: .\INC
  group source
    ../Common/: startup.a51
    ./source/: main.c debug.c a96T418_wdt.c a96T418_bit.c a96T418_usi_i2c.c RegisterMap.c user_timer.c led_driver.c touch_config.c user_function.c a96T418_gpio.c proc.c
  group Note
    ../: note.txt
  group library
    ../library/: library_touch_V105_20230918.LIB
